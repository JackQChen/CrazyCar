# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\user;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32F10x_StdPeriph_Driver\src;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\it;.\sys;.\user\led;.\user\serial;.\user\systick;.\sys;.\user\a4988;.\user\ble;.\user\mpu6050;.\user\oled;.\user\timer;.\user\config;.\user\ADC;.\user\KEY;.\user\crt;.\user\nmswj;.\user\csb;.\user\kaerman
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c Common.c Bluetooth.c nrf24l01.c
    ./user/systick/: systick.c
    ./sys/: sys.c
    ./user/a4988/: A4988.c
    ./user/mpu6050/: yijie.c
    ./user/crt/: crt.c
    ./user/nmswj/: niming_swj.c
    ./user/csb/: csb.c
    ./it/: stm32f10x_it.c
    ./: 修改历史.txt
  group Hardeware
    ./user/led/: led.c
    ./user/timer/: timer.c
    ./user/serial/: serial.c
    ./user/mpu6050/: iic.c mpu6050.c
    ./user/ADC/: adc.c
    ./user/KEY/: key.c
    ./user/: Spi.c
  group Lib
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_i2c.c
  group Core
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
